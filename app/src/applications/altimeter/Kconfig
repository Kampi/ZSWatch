## app/src/applications/altimeter/Kconfig
```kconfig
module = ZSW_ALTIMETER_APP
module-str = ZSW_ALTIMETER_APP
source "subsys/logging/Kconfig.template.log_config"
```
